# Keil uVision project HT6xxx.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: HT60xx +hex
  c flags: Optim=1 wLevel=2
  c define: HT501x
  c include: ..\Libraries\CMSIS\CM0\CoreSupport;..\Libraries\CMSIS\CM0\DeviceSupport;..\Libraries\HT60xx_StdPeriph_Driver;..\Libraries\HT60xx_StdPeriph_Driver\inc;..\Doc;..\users;..\timecntexchange;..\stm32_hal_flashoper
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x15000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Main
    ../Main/: main.c ht6xxx_it.c
    ../Users/: bit_edge.c soft_timer_Filter.c dfinit.c unit_instance.c emu.c flash_filesystem.c globlvar.c disp.c lcdio.c gpio.c pmu.c cmdthread.c formatcmd.c uartio.c systickapp.c eeprom.c public.c PubData.c safedate.c Drv_RTCSPK.c InOut.c hal_delay_us.c TRx.c Meter.c DoCard.c streamio.c globlvar_debug.c indata_oper.c
    ../stm32_hal_flashoper/: Flashsave.c
  group CMSIS
    ../Libraries/CMSIS/CM0/CoreSupport/: core_cm0.c
    ../Libraries/CMSIS/CM0/DeviceSupport/: system_ht6xxx.c
  group StdPeriphDriver
    ../Libraries/HT60xx_StdPeriph_Driver/src/: ht6xxx_cmu.c ht6xxx_exti.c ht6xxx_flash.c ht6xxx_gpio.c ht6xxx_iic.c ht6xxx_lcd.c ht6xxx_pmu.c ht6xxx_reset.c ht6xxx_rtc.c ht6xxx_spi.c ht6xxx_tbs.c ht6xxx_timer.c ht6xxx_uart&7816.c ht6xxx_tdes&rand.c ht6xxx_aes&rand.c ht6xxx_dma.c ht501x_emu.c ht501x_keyscan.c
  group Startup
    ../Libraries/Startup/: startup_ht6x1x.s startup_ht6x2x.s startup_ht501x.s
  group Doc
    ../Doc/: readme.txt example.c aes_example.c
  group timecntexchange
    ../timecntexchange/: GetTimeCnt.c
  group RTC
    ../rtc_app/: rtc_app_ht5019.c
